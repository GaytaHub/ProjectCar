# IAR project SeekFree_Kinetis.ewp, settings and files
configuration MK60_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\seekfree; ..\..\..\Libraries\FatFs; ..\..\..\Libraries\FatFs\option
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SeekFree_Kinetis.srec
  ILINK.IlinkOutputFile: SeekFree_Kinetis.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group drives/inc
    ../../../Libraries/drives/inc/: common.h misc.h MK60DN10_adc.h MK60DN10_cmt.h MK60DN10_dac.h MK60DN10_dma.h MK60DN10_flash.h MK60DN10_ftm.h MK60DN10_gpio.h MK60DN10_i2c.h MK60DN10_lptmr.h MK60DN10_pit.h MK60DN10_port.h MK60DN10_rtc.h MK60DN10_sdhc.h MK60DN10_spi.h MK60DN10_systick.h MK60DN10_uart.h MK60DN10_wdog.h
  group drives/src
    ../../../Libraries/drives/src/: common.c misc.c MK60DN10_adc.c MK60DN10_cmt.c MK60DN10_dac.c MK60DN10_dma.c MK60DN10_flash.c MK60DN10_ftm.c MK60DN10_gpio.c MK60DN10_i2c.c MK60DN10_lptmr.c MK60DN10_pit.c MK60DN10_port.c MK60DN10_rtc.c MK60DN10_sdhc.c MK60DN10_spi.c MK60DN10_systick.c MK60DN10_uart.c MK60DN10_wdog.c
  group fatfs
    ../../../Libraries/FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group seekfree
    ../../../Libraries/seekfree/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_7725.c SEEKFREE_7725.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK60D10.s
    ../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
  group user_c
    ../../USER/src/: Coordinate.c Global.c main.c PID.c Track.c
  group user_h
    ../../USER/inc/: Camera.h Coordinate.h Global.h GraySensor.h isr.h Motor.h PID.h Steering.h Track.h
    ../../../Libraries/drives/inc/: headfile.h MK60DN10_port_cfg.h
  group UserDrive
    ../../USER/src/: Camera.c Encoder.c GraySensor.c Motor.c Steering.c
